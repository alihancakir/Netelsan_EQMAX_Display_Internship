# Keil uVision project MyGPIOProject.uvprojx, settings and files
target Template (6240000::V6.24::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\M031BSP\Library\CMSIS\Core\Include;..\..\M031BSP\Library\Device\Nuvoton\M031\Include;..\..\M031BSP\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../M031BSP/Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../M031BSP/Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../M031BSP/Library/StdDriver/src/: retarget.c clk.c uart.c gpio.c
  group User
    ../: main.c gpio_config.c gpio_config.h MyGPIOProject_config_1.c MyGPIOProject_config_1.h nutool_clkcfg.h
